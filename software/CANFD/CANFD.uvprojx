# Keil uVision project CANFD.uvprojx, settings and files
target GD32E10x (6130001::V6.13.1::.\ARMCLANG)
  device: GD32E103C8 GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x05000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CANFD +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32E10X,GD32E103V_EVAL
  c include: ..\Firmware\GD32\CMSIS\5.6.0\Include;..\Firmware\GD32\GD32E10x\V1.0.0\Include;..\Firmware\GD32\GD32E10x\V1.0.0\Peripherals\inc;.\gd32e103;.\src
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Peripherals
    ../Firmware/GD32/GD32E10x/V1.0.0/Peripherals/src/: gd32e10x_fmc.c gd32e10x_usart.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_rcu.c gd32e10x_fwdgt.c gd32e10x_timer.c gd32e10x_spi.c gd32e10x_can.c gd32e10x_dbg.c
  group gd32e103
    ./gd32e103/: gd32e10x_it.c system_gd32e10x.c startup_gd32e10x.s
  group src
    ./src/: main.c HAL.c
